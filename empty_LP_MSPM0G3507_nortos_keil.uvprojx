# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: .;.\source;.\source\third_party\CMSIS\Core\Include;.\code;.\ml_libs
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ./source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ./: startup_mspm0g350x_uvision.s
    ./: ti_msp_dl_config.c isr.c main.c t2.syscfg
  group code
    ./code/: filter.c filter.h gray_track.c gray_track.h motor.c motor.h pid.c pid.h
  group ml_libs
    ./ml_libs/: clock.c clock.h headfile.h ml_gpio.c ml_gpio.h ml_JY901S.c ml_JY901S.h ml_pwm.c ml_pwm.h ml_tim.c ml_tim.h ml_uart.c ml_uart.h mspm0_i2c.c mspm0_i2c.h oled_hardware_i2c.c oled_hardware_i2c.h oledfont.h
